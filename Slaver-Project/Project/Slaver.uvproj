# Keil uVision project Slaver.uvproj, settings and files
target LCD_V8.07 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Slaver +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\STC15_LIB;..\User\inc
  group LIB
    ../STC15_LIB/: delay.c GPIO.c timer.c USART.C Exti.c
  group MAIN
    ./: STARTUP.A51
    ../User/: main.c
  group CONTROL
    ../User/source/: mode_def.c
  group IR
    ../User/source/: ir.c
  group LCD
    ../User/source/: LCD.c
  group DRIVE
    ../User/source/: HT1621B_Drive.c ringbuffer.c uart.c
