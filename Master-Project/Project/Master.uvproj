# Keil uVision project Master.uvproj, settings and files
target Master_V8.08 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Master +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\STC15_LIB;..\User\inc
  group MAIN
    ./: STARTUP.A51
    ../User/: main.c
  group CONTROL
    ../User/source/: control_new.c distant_analog.c distant_digital.c local.c mode_detect.c
  group DRIVE
    ../User/source/: ringbuffer.c motor.c
  group INPUT
    ../User/source/: data_input.c butterworth_filter.c mlx90316.c spi.c
  group OUTPUT
    ../User/source/: current_output.c
  group PHASESEQ
    ../User/source/: phase_detect.c
  group FLASH
    ../User/source/: data_save.c
  group LIB
    ../STC15_LIB/: ADC.c delay.c EEPROM.c Exti.c GPIO.c PCA.c timer.c USART.C
  group COM
    ../User/source/: com.c
